Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: SD-CM-2-model.ifc
Time: 2026-09-04T11:46:18+00:00
Author: OOO PKF ORION, zavod-orion.ru
Organization: OOO PKF ORION, zavod-orion.ru
Written by: AutoCAD 2024
Made in: AutoCAD 2024
Authorization: OOO PKF ORION, zavod-orion.ru

# IfcBuildingElementProxy, SD-CM-2 Навес «Комфорт 4×8»
In: Площадка
Pset_ManufacturerTypeInformation - Manufacturer: ООО «ПКФ «ОРИОН» · zavod-orion.ru · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: SD-CM-2; ModelReference: Навес «Комфорт 4×8»; ProductionYear: 2026
